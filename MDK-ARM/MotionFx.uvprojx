# Keil uVision project MotionFx.uvprojx, settings and files
target MotionFx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: MotionFx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,USE_IKS01A2
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ../Drivers/BSP/STM32F4xx_Nucleo;   ../Drivers/BSP/Components/lsm6dsl/;   ../Drivers/BSP/Components/lsm303agr/;   ../Drivers/BSP/Components/hts221/;   ../Drivers/BSP/Components/lps22hb/;   ../Drivers/BSP/IKS01A2/;   ../Drivers/BSP/Components/Common/;   ..\STM32_MotionFX_Library\Inc;  ../Middlewares/Third_Party/FreeRTOS/Source/include;  ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;  ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Middleware
    ../STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Application/User
    ../Src/: MotionFX_Manager.c Sensor.c main.c gpio.c crc.c freertos.c app_x-cube-mems1.c tim.c stm32f4xx_nucleo_bus.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/lsm6dsl/: lsm6dsl_reg.c lsm6dsl.c
    ../Drivers/BSP/Components/lsm303agr/: lsm303agr_reg.c lsm303agr.c
    ../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../Drivers/BSP/Components/lps22hb/: lps22hb_reg.c lps22hb.c
  group Drivers/BSP/IKS01A2
    ../Drivers/BSP/IKS01A2/: iks01a2_motion_sensors.c iks01a2_motion_sensors_ex.c iks01a2_env_sensors.c iks01a2_env_sensors_ex.c
software components: CMSIS:CORE 4.3.0
